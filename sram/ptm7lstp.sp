$ Netlist of sram
$ This UUT was automatically generated by:
$ /home/i/iliabautista/Desktop/2-Research/2-Simulations/1-HDL/hspice/sram_script.py
.lib '../models' ptm7lstp
.param vdd_50='vdd/2'
$ UUT individual unit
.subckt inverter in out vdd
$fets
xpfet out in vdd vdd pfet l=lg nfin=1000m
xnfet out in gnd gnd nfet l=lg nfin=1000m
.ends

.subckt sram wl bl blb vdd
xnfet_bl  bl  wl q  q  nfet l=lg nfin=1000m
xnfet_blb blb wl qb qb nfet l=lg nfin=1000m
xq  qb q  vdd inverter
xqb q  qb vdd inverter
.ends
$ Sources
vdd vdd gnd vdd
$bl sources
vin_wl_0 in_wl_0  gnd  pulse(vdd 0v 0.25ns 1p 1p 0.5n 1.0n)
xwl_0 in_wl_0 wl_0 vdd inverter
vin_bl_0 in_bl_0  gnd  pulse(vdd 0v 0ns 1p 1p 0.5n 1.0n)
xbl_0 in_bl_0 bl_0 vdd inverter
xblb_0 vdd  blb_0 vdd inverter

$ Unit Under Test
.subckt model_uut_grid vdd
+wl0 $inputs to model_uut_grid Subckt
+bl0 blb0 $inout to model_uut_grid Subckt
xsram00 wl_00 bl_10 blb_10 vdd sram
.ends
$invoke UUT grid
xmodel_uut_grid vdd
+wl_0 $inputs to model_uut_grid
+bl_10 blb_10 $outputs to model_uut_grid
+model_uut_grid

$ Simulation/Analysis Type
.option post=2 ingold=2
.tran 1p 2nn

.end
